# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c Delay.c MatrixKey.c LCD1602.c
  group include
    ./: Delay.h MatrixKey.h LCD1602.h
